## src/modules/work_wq/Kconfig
```kconfig
menuconfig MODULES_WORK_WQ
	bool "work_wq"
	default n
	---help---
		Enable support for work_wq
```
